<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Club_STM32L431_EVB_M1.ewp</path>
  </project>
  <batchBuild />
</workspace>
